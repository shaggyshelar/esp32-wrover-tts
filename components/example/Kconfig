## components/example/Kconfig
```kconfig
config FOO_ENABLE_BAR
    bool "Enable the Example component."
    help
        This enables the example component.
```
